<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>trace_filename</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>transceiver_exp</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import log10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from os import sep</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>snr_db</value></param>
<param><key>value</key><value>20</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Adjust SNR for the experiments up to the max value</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>trace_filename</value></param>
<param><key>value</key><value>/home/claro/constructive_interf/data/exp6/ID2_Repeater.data/capture.data</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>Change first digit to get points in the BER vs SNR curves</value></param>
</block>
<block>
<key>EbNo_Noise_Channel</key>
<param><key>id</key><value>EbNo_Noise_Channel_0</value></param>
<param><key>EbNo</key><value>snr_db</value></param>
</block>
<block>
<key>ieee802_15_4_phy_chips</key>
<param><key>id</key><value>ieee802_15_4_phy_chips_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>sep.join((output_dir, "sensor_chips_%02.0f.pcap" % (snr_db,)))</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>sep.join((output_dir, "sensor_%02.0f.pcap" % (snr_db,)))</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0_0</value></param>
<param><key>tech</key><value>195</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>tech</key><value>195</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_dir</value></param>
<param><key>value</key><value>/tmp</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>o</value></param>
</block>
<connection><source_block_id>ieee802_15_4_phy_chips_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>EbNo_Noise_Channel_0</source_block_id><sink_block_id>ieee802_15_4_phy_chips_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>EbNo_Noise_Channel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_phy_chips_0</source_block_id><sink_block_id>foo_wireshark_connector_0_0</sink_block_id><source_key>rxout_chips</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_phy_chips_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>rxout</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
